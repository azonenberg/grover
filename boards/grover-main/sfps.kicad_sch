File: boards/grover-main/sfps.kicad_sch (KiCad schematic)
At the start: 52 parts

Commit message: Continued initial schematic capture
Parts:
- gave numbers to parts that had none: 52
