File: boards/grover-main/coax-ios.kicad_sch (KiCad schematic)
At the start: 34 parts

Commit message: Continued initial schematic capture
Parts:
- gave numbers to parts that had none: 34
